# IAR project sf.ewp, settings and files
configuration cluster_88 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCDefines: CONFIG_IARLIB
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.PreInclude: ..\..\..\..\sf\projects\cluster_88\config.h
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\boards\d3_disp\build\cluster_88\iar\sf; ..\..\..\..\..\..\.\include; ..\..\..\..\..\..\arch\arm\include; ..\..\..\..\..\..\drivers; ..\..\..\..\..\..\boards\include; ..\..\..\..\..\..\boards\d3_disp\build\cluster_88\iar\sf\configs; ..\..\..\..\..\..\boards\configs\include; ..\..\..\..\..\..\arch\arm\armv7-r\include; ..\..\..\..\..\..\arch\arm\d3; ..\..\..\..\..\..\boards\d3_disp\sf; ..\..\..\..\..\..\boards\d3_disp\sf\include; ..\..\..\..\..\..\lib\checksum\include; ..\..\..\..\..\..\lib\debug\include; ..\..\..\..\..\..\lib\disk\include; ..\..\..\..\..\..\lib\libc\iar\include; ..\..\..\..\..\..\lib\partition\include; ..\..\..\..\..\..\lib\sd_boot_img\include; ..\..\..\..\..\..\middleware\CLI\include; ..\..\..\..\..\..\middleware\coredbg; ..\..\..\..\..\..\middleware\coredbg\include; ..\..\..\..\..\..\middleware\fatfs\include; ..\..\..\..\..\..\middleware\fatfs\include; ..\..\..\..\..\..\middleware\gpu_hal; ..\..\..\..\..\..\middleware\gpu_hal\inc; ..\..\..\..\..\..\middleware\gpu_hal\include; ..\..\..\..\..\..\middleware\littlevgl; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7; ..\..\..\..\..\..\middleware\littlevgl\lvgl_sdrv; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_core; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_hal; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_widgets; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_font; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_misc; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_themes; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_draw; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_gpu; ..\..\..\..\..\..\middleware\littlevgl\lvgl_sdrv\display; ..\..\..\..\..\..\middleware\littlevgl\lvgl_sdrv\decoder\lodepng; ..\..\..\..\..\..\middleware\littlevgl\lvgl_sdrv\fs; ..\..\..\..\..\..\middleware\littlevgl\lvgl_sdrv\gpu; ..\..\..\..\..\..\middleware\littlevgl\include; ..\..\..\..\..\..\middleware\lodepng; ..\..\..\..\..\..\middleware\lodepng\inc; ..\..\..\..\..\..\middleware\lodepng\include; ..\..\..\..\..\..\middleware\mem_rw\include; ..\..\..\..\..\..\middleware\mjpeg; ..\..\..\..\..\..\middleware\mjpeg\include; ..\..\..\..\..\..\middleware\reboot; ..\..\..\..\..\..\middleware\reboot\include; ..\..\..\..\..\..\middleware\tjpgdec; ..\..\..\..\..\..\middleware\tjpgdec\include; ..\..\..\..\..\..\rtos\FreeRTOS\include; ..\..\..\..\..\..\drivers\taishan\btm; ..\..\..\..\..\..\drivers\taishan\btm\include; ..\..\..\..\..\..\drivers\taishan\clk; ..\..\..\..\..\..\drivers\taishan\clk\include; ..\..\..\..\..\..\drivers\taishan\dispss\include; ..\..\..\..\..\..\drivers\taishan\eth\include; ..\..\..\..\..\..\drivers\taishan\g2dlite\include; ..\..\..\..\..\..\drivers\taishan\gpio\include; ..\..\..\..\..\..\drivers\taishan\hwmutex\include; ..\..\..\..\..\..\drivers\taishan\i2c\include; ..\..\..\..\..\..\drivers\taishan\mbox\include; ..\..\..\..\..\..\drivers\taishan\mmc\include; ..\..\..\..\..\..\drivers\taishan\pinctrl\include; ..\..\..\..\..\..\drivers\taishan\reset\include; ..\..\..\..\..\..\drivers\taishan\scr\include; ..\..\..\..\..\..\drivers\taishan\sdramc\include; ..\..\..\..\..\..\drivers\taishan\spi_nor\include; ..\..\..\..\..\..\drivers\taishan\uart; ..\..\..\..\..\..\drivers\taishan\uart\include; ..\..\..\..\..\..\drivers\taishan\vic\include; ..\..\..\..\..\..\examples\taishan\ota\inc; ..\..\..\..\..\..\examples\taishan\ota\include; ..\..\..\..\..\..\examples\taishan\application\bootanimation; ..\..\..\..\..\..\examples\taishan\application\bootanimation\inc; ..\..\..\..\..\..\examples\taishan\application\bootanimation\include; ..\..\..\..\..\..\examples\taishan\application\cluster; ..\..\..\..\..\..\examples\taishan\application\cluster\inc; ..\..\..\..\..\..\middleware\sd_graphics\inc; ..\..\..\..\..\..\examples\taishan\application\cluster\include; ..\..\..\..\..\..\examples\taishan\application\launcher; ..\..\..\..\..\..\examples\taishan\application\launcher\inc; ..\..\..\..\..\..\examples\taishan\application\launcher\include; ..\..\..\..\..\..\middleware\lwip\src\include; ..\..\..\..\..\..\middleware\lwip\contrib\ports\cmsis_os2\include; ..\..\..\..\..\..\middleware\lwip\contrib; ..\..\..\..\..\..\middleware\lwip\include; ..\..\..\..\..\..\arch\arm\armv7-r; ..\..\..\..\..\..\rtos\FreeRTOS\Config; ..\..\..\..\..\..\rtos\FreeRTOS\Source\include; ..\..\..\..\..\..\rtos\FreeRTOS\Source\portable\IAR\ARM_CR5; ..\..\..\..\sf\projects\cluster_88; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: ASSEMBLY; __ICCARM__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sf.bin
  prebuild: ..\..\..\..\..\..\tools\iarprebuild.bat d3_disp cluster_88 sf ..\..\..\..\..\..
  postbuild: ..\..\..\..\..\..\tools\sdtools\package.bat d3_disp cluster_88
  ILINK.IlinkOutputFile: sf.out
  ILINK.IlinkIcfFile: ..\..\..\..\sf\scripts\iar\sdram.icf
  ILINK.IlinkExtraOptions: --config_def; MEMBASE=0x404000; --config_def; MEMSIZE=0x3FC000; --config_def; TCMBASE=0x1900000; --config_def; TCMSIZE=0x20000; --config_def; NONEECCBASE=0x800000; --config_def; NONEECCSIZE=0; --config_def; SDRAMBASE=0x30000000; --config_def; SDRAMSIZE=0x4000000
  ILINK.IlinkProgramEntryLabel: _start
  group usrlibs
    ../../../../../../drivers/taishan/dispss/libs/: libdispss.a
    ../../../../../../drivers/taishan/g2dlite/libs/: libg2dlite.a
    ../../../../../../middleware/sd_graphics/: libsd_graphics.a
  group examples
    ../../../../../../examples/taishan/ota/: ota.c ota_eth.c
    ../../../../../../examples/taishan/application/bootanimation/src/: animation.c player.c decoder.c render.c
    ../../../../../../examples/taishan/application/cluster/src/: lv_demo_cluster.c
    ../../../../../../examples/taishan/application/launcher/src/: launcher.c
  group rtos
    ../../../../../../rtos/FreeRTOS/Source/portable/IAR/ARM_CR5/: portASM.S port.c
    ../../../../../../rtos/FreeRTOS/Source/portable/Common/: irq_wrapper.c timer_wrapper.c
    ../../../../../../rtos/FreeRTOS/Source/portable/CMSIS/: freertos_cmsis.c
    ../../../../../../rtos/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group middleware
    ../../../../../../middleware/CLI/: CLI.c CLI_console.c CLI_task.c
    ../../../../../../middleware/coredbg/: taishan_coredbg.c
    ../../../../../../middleware/fatfs/: diskio_sdrv.c ff.c ffsystem.c ffunicode.c ff_unittest.c
    ../../../../../../middleware/gpu_hal/src/: gpu_hal.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_core/: lv_group.c lv_indev.c lv_disp.c lv_obj.c lv_refr.c lv_style.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_widgets/: lv_arc.c lv_rear_guide_line.c lv_bar.c lv_checkbox.c lv_cpicker.c lv_dropdown.c lv_keyboard.c lv_line.c lv_msgbox.c lv_spinner.c lv_roller.c lv_table.c lv_tabview.c lv_tileview.c lv_btn.c lv_calendar.c lv_chart.c lv_canvas.c lv_gauge.c lv_label.c lv_list.c lv_slider.c lv_textarea.c lv_spinbox.c lv_btnmatrix.c lv_cont.c lv_img.c lv_imgbtn.c lv_led.c lv_linemeter.c lv_page.c lv_switch.c lv_win.c lv_objmask.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_12_subpx.c lv_font_montserrat_28_compressed.c lv_font_unscii_8.c lv_font_dejavu_16_persian_hebrew.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_misc/: lv_area.c lv_task.c lv_fs.c lv_anim.c lv_mem.c lv_ll.c lv_color.c lv_txt.c lv_txt_ap.c lv_math.c lv_log.c lv_gc.c lv_utils.c lv_async.c lv_printf.c lv_bidi.c lv_debug.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_themes/: lv_theme.c lv_theme_material.c lv_theme_mono.c lv_theme_empty.c lv_theme_template.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_draw/: lv_draw_mask.c lv_draw_blend.c lv_draw_rect.c lv_draw_label.c lv_draw_line.c lv_draw_img.c lv_draw_arc.c lv_draw_triangle.c lv_img_decoder.c lv_img_cache.c lv_img_buf.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_gpu/: lv_gpu_stm32_dma2d.c
    ../../../../../../middleware/littlevgl/lvgl_sdrv/: lvgl_gui.c
    ../../../../../../middleware/littlevgl/lvgl_sdrv/display/: lvgl_disp_drv.c
    ../../../../../../middleware/littlevgl/lvgl_sdrv/decoder/lodepng/: lv_png.c
    ../../../../../../middleware/littlevgl/lvgl_sdrv/fs/: fatfs_semidrive.c
    ../../../../../../middleware/littlevgl/lvgl_sdrv/gpu/: lv_gpu_sdrv_dma2d.c
    ../../../../../../middleware/lodepng/src/: lodepng.c
    ../../../../../../middleware/mem_rw/: mem_rw.c
    ../../../../../../middleware/mjpeg/: mjpeg.c
    ../../../../../../middleware/reboot/: reboot_taishan_global.c
    ../../../../../../middleware/tjpgdec/: tjpgd.c
    ../../../../../../middleware/lwip/contrib/ports/cmsis_os2/: sys_arch.c netdev.c net_tool.c
    ../../../../../../middleware/lwip/src/apps/lwiperf/: lwiperf.c
    ../../../../../../middleware/lwip/src/apps/tftp/: tftp.c
    ../../../../../../middleware/lwip/src/core/: init.c def.c dns.c inet_chksum.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c altcp.c altcp_alloc.c altcp_tcp.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4_frag.c ip4.c ip4_addr.c
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../middleware/lwip/src/netif/: ethernet.c
    ../../../../../../middleware/lwip/contrib/apps/ping/: ping.c
  group lib
    ../../../../../../lib/checksum/: adler32.c crc4.c crc16.c crc32.c md5.c
    ../../../../../../lib/debug/: debug.c errno.c
    ../../../../../../lib/disk/: disk_api.c disk_ram.c disk_mmc.c disk_norflash.c
    ../../../../../../lib/libc/iar/: io.c malloc.c
    ../../../../../../lib/partition/: partition_parser.c ab_partition_parser.c partition_disk_io.c
    ../../../../../../lib/sd_boot_img/: sd_boot_img.c
  group arch
    ../../../../../../arch/arm/armv7-r/: arm_arch.c arm_irq.c arm_fpu.c arm_mpu.c arm_faults.c
    ../../../../../../arch/arm/armv7-r/iar/: arm_atomic.S arm_start.S arm_cache.S arm_tcm.S arm_exceptions.S arm_saveusercontext.S arm_fullcontextrestore.S arm_switchcontext.S
  group boards
    ../../../../../../boards/: board.c
    ../../../../../../boards/d3_disp/build/cluster_88/iar/sf/configs/: clock_cfg_od.c clock_cfg_nd.c dispss_cfg.c pinmux_cfg.c mmc_cfg.c ram_cfg.c fee_cfg.c eth_cfg.c dma_cfg.c g2dlite_cfg.c rstgen_cfg.c smc_cfg.c cam_cfg.c cpufreq_cfg.c rtc_cfg.c timer_cfg.c i2c_cfg.c i2s_cfg.c adc_cfg.c asw_cfg.c pdm_cfg.c mpu_cfg.c norflash_cfg.c codec_cfg.c can_cfg.c pinmux_cfg_z1.c scr_cfg.c mbox_cfg.c uart_cfg.c sdramc_cfg.c pmu_cfg.c touch_cfg.c pwm_cfg.c remap_cfg.c pinmux.c
    ../../../../../../boards/d3_disp/sf/: sf_board.c
    ../../../../../../boards/d3_disp/sf/projects/cluster_88/: main.c
  group drivers
    ../../../../../../drivers/: clk.c gpio.c hwmutex.c i2c.c irq.c mbox.c reset.c scr.c spi_nor.c timer.c arch_timer.c uart.c
    ../../../../../../drivers/taishan/btm/: sdrv_btm.c sdrv_btm_drv.c
    ../../../../../../drivers/taishan/clk/: taishan_ckgen_drv.c taishan_ckgen.c taishan_pll_drv.c taishan_pll.c
    ../../../../../../drivers/taishan/dispss/lcm/: lvds_lt9211_to_mipi_480x1920_lcd.c sdrv_panels.c
    ../../../../../../drivers/taishan/dispss/lcm/lt9211/: lt9211.c
    ../../../../../../drivers/taishan/dispss/: sdrv_dispss.c
    ../../../../../../drivers/taishan/eth/: dwc_eth.c dw_mac_lld.c
    ../../../../../../drivers/taishan/eth/phy/: phy.c dp83848.c rtl9010.c
    ../../../../../../drivers/taishan/g2dlite/: sdrv_g2dlite.c
    ../../../../../../drivers/taishan/gpio/: taishan_gpio.c
    ../../../../../../drivers/taishan/hwmutex/: taishan_hwmutex.c
    ../../../../../../drivers/taishan/i2c/: sdrv_i2c_drv.c sdrv_i2c.c
    ../../../../../../drivers/taishan/mbox/: sdrv_taishan_mbox_drv.c sdrv_mbox.c
    ../../../../../../drivers/taishan/mmc/core/: mmc_sdhci.c
    ../../../../../../drivers/taishan/mmc/host/: sdhci.c mmc_sehc.c
    ../../../../../../drivers/taishan/pinctrl/: taishan_pinctrl.c taishan_pinctrl_is.c
    ../../../../../../drivers/taishan/reset/: taishan_reset_drv.c taishan_rstgen.c
    ../../../../../../drivers/taishan/scr/: scr_lld.c
    ../../../../../../drivers/taishan/sdramc/: taishan_sdramc.c
    ../../../../../../drivers/taishan/spi_nor/: taishan_xspi.c taishan_xspi_drv.c
    ../../../../../../drivers/taishan/uart/: sdrv_uart_drv.c sdrv_uart.c
    ../../../../../../drivers/taishan/vic/: sdrv_vic.c
