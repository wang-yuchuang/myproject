# IAR project sf.ewp, settings and files
configuration flashloader (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCDefines: CONFIG_IARLIB
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.PreInclude: ..\..\..\..\sf\projects\flashloader\config.h
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\boards\d3_gateway\build\flashloader\iar\sf; ..\..\..\..\..\..\.\include; ..\..\..\..\..\..\arch\arm\include; ..\..\..\..\..\..\drivers; ..\..\..\..\..\..\boards\include; ..\..\..\..\..\..\boards\d3_gateway\build\flashloader\iar\sf\configs; ..\..\..\..\..\..\boards\configs\include; ..\..\..\..\..\..\arch\arm\armv7-r\include; ..\..\..\..\..\..\arch\arm\d3; ..\..\..\..\..\..\boards\d3_gateway\sf; ..\..\..\..\..\..\boards\d3_gateway\sf\include; ..\..\..\..\..\..\lib\checksum\include; ..\..\..\..\..\..\lib\debug\include; ..\..\..\..\..\..\lib\libc\iar\include; ..\..\..\..\..\..\lib\sd_boot_img\include; ..\..\..\..\..\..\middleware\CLI\include; ..\..\..\..\..\..\middleware\flashloader\include; ..\..\..\..\..\..\rtos\BareMetal\include; ..\..\..\..\..\..\drivers\taishan\clk; ..\..\..\..\..\..\drivers\taishan\clk\include; ..\..\..\..\..\..\drivers\taishan\gpio\include; ..\..\..\..\..\..\drivers\taishan\pinctrl\include; ..\..\..\..\..\..\drivers\taishan\reset\include; ..\..\..\..\..\..\drivers\taishan\scr\include; ..\..\..\..\..\..\drivers\taishan\spi_nor\include; ..\..\..\..\..\..\drivers\taishan\uart; ..\..\..\..\..\..\drivers\taishan\uart\include; ..\..\..\..\..\..\arch\arm\armv7-r; ..\..\..\..\..\..\middleware\flashloader\include; ..\..\..\..\sf\projects\flashloader; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: ASSEMBLY; __ICCARM__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sf.bin
  prebuild: ..\..\..\..\..\..\tools\iarprebuild.bat d3_gateway flashloader sf ..\..\..\..\..\..
  postbuild: ..\..\..\..\..\..\tools\sdtools\package.bat d3_gateway flashloader
  ILINK.IlinkOutputFile: sf.out
  ILINK.IlinkIcfFile: ..\..\..\..\sf\scripts\iar\flashloader.icf
  ILINK.IlinkExtraOptions: --config_def; MEMBASE=0x500000; --config_def; MEMSIZE=0x100000; --config_def; FLASHLOADER_BUFFER_SIZE=0x4000; --redirect; osDelay=mdelay
  ILINK.IlinkProgramEntryLabel: _start
  group rtos
    ../../../../../../rtos/BareMetal/IAR/ARM_CR5/: exceptions.S
    ../../../../../../rtos/BareMetal/: irq_wrapper.c baremetal_cmsis.c
  group middleware
    ../../../../../../middleware/CLI/: CLI.c CLI_console.c CLI_task.c
    ../../../../../../middleware/flashloader/: flash_loader_asm.s flash_loader.c flash_loader_implement.c flash_wrapper.c bpt_update.c
  group lib
    ../../../../../../lib/checksum/: adler32.c crc4.c crc16.c crc32.c md5.c
    ../../../../../../lib/debug/: debug.c errno.c
    ../../../../../../lib/libc/iar/: io.c
    ../../../../../../lib/sd_boot_img/: sd_boot_img.c
  group arch
    ../../../../../../arch/arm/armv7-r/: arm_arch.c arm_irq.c arm_fpu.c arm_mpu.c arm_faults.c
    ../../../../../../arch/arm/armv7-r/iar/: arm_atomic.S arm_start.S arm_cache.S arm_tcm.S arm_exceptions.S arm_saveusercontext.S arm_fullcontextrestore.S arm_switchcontext.S
  group boards
    ../../../../../../boards/: board.c
    ../../../../../../boards/d3_gateway/build/flashloader/iar/sf/configs/: clock_cfg_nd.c rstgen_cfg.c pinmux_cfg.c uart_cfg.c core_shm_cfg.c hwmutex_cfg.c rpmsg_service_cfg.c mmc_cfg.c ram_cfg.c fee_cfg.c eth_cfg.c clock_cfg_od.c sbc_cfg.c dma_cfg.c scr_cfg.c rtc_cfg.c can_cfg.c cpufreq_cfg.c reboot_cfg.c sent_cfg.c timer_cfg.c i2c_cfg.c i2s_cfg.c adc_cfg.c pwm_cfg.c mpu_cfg.c norflash_cfg.c codec_cfg.c pdm_cfg.c mbox_cfg.c pmu_cfg.c lin_cfg.c smc_cfg.c pinmux.c
    ../../../../../../boards/d3_gateway/sf/: sf_board.c
    ../../../../../../boards/d3_gateway/sf/projects/flashloader/: main.c
  group drivers
    ../../../../../../drivers/: clk.c gpio.c reset.c scr.c spi_nor.c uart.c
    ../../../../../../drivers/taishan/clk/: taishan_ckgen_drv.c taishan_ckgen.c taishan_pll_drv.c taishan_pll.c
    ../../../../../../drivers/taishan/gpio/: taishan_gpio.c
    ../../../../../../drivers/taishan/pinctrl/: taishan_pinctrl.c taishan_pinctrl_is.c
    ../../../../../../drivers/taishan/reset/: taishan_reset_drv.c taishan_rstgen.c
    ../../../../../../drivers/taishan/scr/: scr_lld.c
    ../../../../../../drivers/taishan/spi_nor/: taishan_xspi.c taishan_xspi_drv.c
    ../../../../../../drivers/taishan/uart/: sdrv_uart_drv.c sdrv_uart.c
