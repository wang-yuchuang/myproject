# IAR project sf.ewp, settings and files
configuration ref (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCDefines: CONFIG_IARLIB
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.PreInclude: ..\..\..\..\sf\projects\ref\config.h
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\boards\d3_gateway\build\ref\iar\sf; ..\..\..\..\..\..\.\include; ..\..\..\..\..\..\arch\arm\include; ..\..\..\..\..\..\drivers; ..\..\..\..\..\..\boards\include; ..\..\..\..\..\..\boards\d3_gateway\build\ref\iar\sf\configs; ..\..\..\..\..\..\boards\configs\include; ..\..\..\..\..\..\arch\arm\armv7-r\include; ..\..\..\..\..\..\arch\arm\d3; ..\..\..\..\..\..\boards\d3_gateway\sf; ..\..\..\..\..\..\boards\d3_gateway\sf\include; ..\..\..\..\..\..\lib\buffqueue\include; ..\..\..\..\..\..\lib\checksum\include; ..\..\..\..\..\..\lib\debug\include; ..\..\..\..\..\..\lib\disk\include; ..\..\..\..\..\..\lib\libc\iar\include; ..\..\..\..\..\..\lib\partition\include; ..\..\..\..\..\..\lib\sd_boot_img\include; ..\..\..\..\..\..\middleware\CLI\include; ..\..\..\..\..\..\middleware\coremark\include; ..\..\..\..\..\..\middleware\cu; ..\..\..\..\..\..\middleware\cu\include; ..\..\..\..\..\..\middleware\dhrystone\include; ..\..\..\..\..\..\middleware\fatfs\include; ..\..\..\..\..\..\middleware\fatfs\include; ..\..\..\..\..\..\middleware\flops\include; ..\..\..\..\..\..\middleware\mem_rw\include; ..\..\..\..\..\..\middleware\minimp3\include; ..\..\..\..\..\..\middleware\minimp3\include; ..\..\..\..\..\..\middleware\reboot; ..\..\..\..\..\..\middleware\reboot\include; ..\..\..\..\..\..\middleware\rpmsg\include; ..\..\..\..\..\..\middleware\rpmsg\include; ..\..\..\..\..\..\middleware\rpmsg_service; ..\..\..\..\..\..\middleware\rpmsg_service\include; ..\..\..\..\..\..\middleware\usb\include; ..\..\..\..\..\..\middleware\usb\include; ..\..\..\..\..\..\rtos\FreeRTOS\include; ..\..\..\..\..\..\drivers\taishan\acmp; ..\..\..\..\..\..\drivers\taishan\acmp\include; ..\..\..\..\..\..\drivers\taishan\adc\include; ..\..\..\..\..\..\drivers\taishan\btm; ..\..\..\..\..\..\drivers\taishan\btm\include; ..\..\..\..\..\..\drivers\taishan\can\include; ..\..\..\..\..\..\drivers\taishan\clk; ..\..\..\..\..\..\drivers\taishan\clk\include; ..\..\..\..\..\..\drivers\taishan\crypto\osr_crypto\; ..\..\..\..\..\..\drivers\taishan\crypto\osr_crypto\cacc\; ..\..\..\..\..\..\drivers\taishan\crypto\osr_crypto\include; ..\..\..\..\..\..\drivers\taishan\dma\include; ..\..\..\..\..\..\drivers\taishan\epwm; ..\..\..\..\..\..\drivers\taishan\epwm\include; ..\..\..\..\..\..\drivers\taishan\eth\include; ..\..\..\..\..\..\drivers\taishan\etimer; ..\..\..\..\..\..\drivers\taishan\etimer\include; ..\..\..\..\..\..\drivers\taishan\fuse\include; ..\..\..\..\..\..\drivers\taishan\gpio\include; ..\..\..\..\..\..\drivers\taishan\hwmutex\include; ..\..\..\..\..\..\drivers\taishan\i2c\include; ..\..\..\..\..\..\drivers\taishan\lin\include; ..\..\..\..\..\..\drivers\taishan\mbox\include; ..\..\..\..\..\..\drivers\taishan\mmc\include; ..\..\..\..\..\..\drivers\taishan\pinctrl\include; ..\..\..\..\..\..\drivers\taishan\pmu; ..\..\..\..\..\..\drivers\taishan\pmu\include; ..\..\..\..\..\..\drivers\taishan\power\include; ..\..\..\..\..\..\drivers\taishan\reset\include; ..\..\..\..\..\..\drivers\taishan\rtc\include; ..\..\..\..\..\..\drivers\taishan\scr\include; ..\..\..\..\..\..\drivers\taishan\sem; ..\..\..\..\..\..\drivers\taishan\sem\include; ..\..\..\..\..\..\drivers\taishan\sensor\include; ..\..\..\..\..\..\drivers\taishan\sent\include; ..\..\..\..\..\..\drivers\taishan\smc\include; ..\..\..\..\..\..\drivers\taishan\snd\include; ..\..\..\..\..\..\drivers\taishan\spi; ..\..\..\..\..\..\drivers\taishan\spi\include; ..\..\..\..\..\..\drivers\taishan\spi_nor\include; ..\..\..\..\..\..\drivers\taishan\tmonitor\include; ..\..\..\..\..\..\drivers\taishan\uart; ..\..\..\..\..\..\drivers\taishan\uart\include; ..\..\..\..\..\..\drivers\taishan\vic\include; ..\..\..\..\..\..\drivers\taishan\watchdog\include; ..\..\..\..\..\..\drivers\taishan\xtrg; ..\..\..\..\..\..\drivers\taishan\xtrg\include; ..\..\..\..\..\..\examples\taishan\ota\inc; ..\..\..\..\..\..\examples\taishan\ota\include; ..\..\..\..\..\..\middleware\usb\uC-USBD; ..\..\..\..\..\..\middleware\usb\uC-USBD\include; ..\..\..\..\..\..\middleware\usb\uC-USBH; ..\..\..\..\..\..\middleware\usb\uC-USBH\include; ..\..\..\..\..\..\examples\taishan\application\mp3_dec\include; ..\..\..\..\..\..\examples\taishan\boot\global_reboot\include; ..\..\..\..\..\..\examples\taishan\drivers\acmp\include; ..\..\..\..\..\..\examples\taishan\drivers\adc\include; ..\..\..\..\..\..\examples\taishan\drivers\analog_in\include; ..\..\..\..\..\..\examples\taishan\drivers\analog_out\include; ..\..\..\..\..\..\examples\taishan\drivers\canfd\include; ..\..\..\..\..\..\examples\taishan\drivers\dma\include; ..\..\..\..\..\..\examples\taishan\drivers\hsd\include; ..\..\..\..\..\..\examples\taishan\drivers\led\include; ..\..\..\..\..\..\examples\taishan\drivers\lin\include; ..\..\..\..\..\..\examples\taishan\drivers\lsd\include; ..\..\..\..\..\..\examples\taishan\drivers\mbox\include; ..\..\..\..\..\..\examples\taishan\drivers\pmu\include; ..\..\..\..\..\..\examples\taishan\drivers\rpmsg\include; ..\..\..\..\..\..\examples\taishan\drivers\sent\include; ..\..\..\..\..\..\examples\taishan\drivers\watchdog\include; ..\..\..\..\..\..\examples\taishan\util\gating\include; ..\..\..\..\..\..\examples\taishan\util\mem_section\include; ..\..\..\..\..\..\examples\taishan\util\power_monitor\include; ..\..\..\..\..\..\examples\taishan\util\pvt\include; ..\..\..\..\..\..\middleware\lwip\src\include; ..\..\..\..\..\..\middleware\lwip\contrib\ports\cmsis_os2\include; ..\..\..\..\..\..\middleware\lwip\contrib; ..\..\..\..\..\..\middleware\lwip\include; ..\..\..\..\..\..\examples\taishan\drivers\usb\USBD_Serial\include; ..\..\..\..\..\..\examples\taishan\drivers\usb\USBH_HID_MSC\include; ..\..\..\..\..\..\arch\arm\armv7-r; ..\..\..\..\..\..\middleware\coremark\ssdk; ..\..\..\..\..\..\middleware\coremark; ..\..\..\..\..\..\rtos\FreeRTOS\Config; ..\..\..\..\..\..\rtos\FreeRTOS\Source\include; ..\..\..\..\..\..\rtos\FreeRTOS\Source\portable\IAR\ARM_CR5; ..\..\..\..\..\..\include\driver\taishan\spi\; ..\..\..\..\sf\projects\ref; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: ASSEMBLY; __ICCARM__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sf.bin
  prebuild: ..\..\..\..\..\..\tools\iarprebuild.bat d3_gateway ref sf ..\..\..\..\..\..
  postbuild: ..\..\..\..\..\..\tools\sdtools\package.bat d3_gateway ref
  ILINK.IlinkOutputFile: sf.out
  ILINK.IlinkIcfFile: ..\..\..\..\sf\scripts\iar\ram.icf
  ILINK.IlinkExtraOptions: --config_def; MEMBASE=0x404000; --config_def; MEMSIZE=0x1F4000; --config_def; TCMBASE=0x1900000; --config_def; TCMSIZE=0x20000; --config_def; NONEECCBASE=0x800000; --config_def; NONEECCSIZE=0
  ILINK.IlinkProgramEntryLabel: _start
  group examples
    ../../../../../../examples/taishan/ota/: ota.c ota_eth.c
    ../../../../../../examples/taishan/application/mp3_dec/: mp3_player.c
    ../../../../../../examples/taishan/boot/global_reboot/: global_reboot.c
    ../../../../../../examples/taishan/drivers/acmp/: acmp_test.c
    ../../../../../../examples/taishan/drivers/adc/: taishan_adc_test.c
    ../../../../../../examples/taishan/drivers/analog_in/: analog_in_demo.c
    ../../../../../../examples/taishan/drivers/analog_out/: analog_out_demo.c
    ../../../../../../examples/taishan/drivers/canfd/: can_demo.c
    ../../../../../../examples/taishan/drivers/dma/: app_dma.c
    ../../../../../../examples/taishan/drivers/hsd/: hsd_demo.c
    ../../../../../../examples/taishan/drivers/led/: led_demo.c
    ../../../../../../examples/taishan/drivers/lin/: sdrv_lin_demo.c
    ../../../../../../examples/taishan/drivers/lsd/: lsd_demo.c
    ../../../../../../examples/taishan/drivers/mbox/: sdrv_taishan_mbox_test.c
    ../../../../../../examples/taishan/drivers/pmu/: taishan_pmu_demo.c
    ../../../../../../examples/taishan/drivers/rpmsg/: taishan_rpmsg_test.c
    ../../../../../../examples/taishan/drivers/sent/: sdrv_sent_test.c
    ../../../../../../examples/taishan/drivers/watchdog/: watchdog_demo.c
    ../../../../../../examples/taishan/util/gating/: power_gate_e3.c clk_gate_e3.c
    ../../../../../../examples/taishan/util/mem_section/: mem_section_example.c
    ../../../../../../examples/taishan/util/power_monitor/: power_monitor.c power_monitor_d3_gateway.c
    ../../../../../../examples/taishan/util/pvt/: taishan_pvt_example.c
    ../../../../../../examples/taishan/drivers/usb/USBD_Serial/: app_usbd.c app_usbd_cdc.c
    ../../../../../../examples/taishan/drivers/usb/USBH_HID_MSC/: app_usbh.c
    ../../../../../../examples/taishan/drivers/usb/USBH_HID_MSC/HID/: app_usbh_mouse.c app_usbh_keyboard.c app_usbh_hid.c
    ../../../../../../examples/taishan/drivers/usb/USBH_HID_MSC/MSC/FatFs/: app_usbh_msc.c
  group rtos
    ../../../../../../rtos/FreeRTOS/Source/portable/IAR/ARM_CR5/: portASM.S port.c
    ../../../../../../rtos/FreeRTOS/Source/portable/Common/: irq_wrapper.c timer_wrapper.c
    ../../../../../../rtos/FreeRTOS/Source/portable/CMSIS/: freertos_cmsis.c
    ../../../../../../rtos/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group middleware
    ../../../../../../middleware/CLI/: CLI.c CLI_console.c CLI_task.c
    ../../../../../../middleware/coremark/ssdk/: core_portme.c
    ../../../../../../middleware/coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
    ../../../../../../middleware/cu/: cu.c
    ../../../../../../middleware/dhrystone/v2.1/: dhry_1.c dhry_2.c dhry.c
    ../../../../../../middleware/fatfs/: diskio_sdrv.c ff.c ffsystem.c ffunicode.c ff_unittest.c
    ../../../../../../middleware/flops/: whetstone.c linpack.c flops.c flops_main.c
    ../../../../../../middleware/mem_rw/: mem_rw.c
    ../../../../../../middleware/minimp3/: minimp3.c
    ../../../../../../middleware/reboot/: reboot_taishan_global.c
    ../../../../../../middleware/rpmsg/: rpmsg.c rpmsg_ns.c rpmsg_channel.c
    ../../../../../../middleware/rpmsg/virtio/: rpmsg_env.c rpmsg_platform.c rpmsg_virtio.c virtqueue.c
    ../../../../../../middleware/rpmsg/ipcc/: rpmsg_ipcc.c
    ../../../../../../middleware/rpmsg_service/: rpmsg_service.c rpmsg_echo.c
    ../../../../../../middleware/usb/: lib_mem.c usb_bsp_e3.c
    ../../../../../../middleware/usb/uC-USBD/Source/: usbd_core.c usbd_ep.c
    ../../../../../../middleware/usb/uC-USBD/OS/cmsis_os/: usbd_os.c
    ../../../../../../middleware/usb/uC-USBD/Drivers/Renesas_USBHS/: usbd_drv_renesas_usbhs.c
    ../../../../../../middleware/usb/uC-USBD/Drivers/drv_lib/: usbd_drv_lib.c
    ../../../../../../middleware/usb/uC-USBD/Class/CDC/: usbd_cdc.c
    ../../../../../../middleware/usb/uC-USBD/Class/CDC/ACM/: usbd_acm_serial.c
    ../../../../../../middleware/usb/uC-USBH/Source/: usbh_core.c usbh_class.c usbh_hub.c
    ../../../../../../middleware/usb/uC-USBH/OS/cmsis_os/: usbh_os.c
    ../../../../../../middleware/usb/uC-USBH/HCD/EHCI/: usbh_hcd_ehci.c
    ../../../../../../middleware/usb/uC-USBH/HCD/OHCI/: usbh_hcd_ohci.c
    ../../../../../../middleware/usb/uC-USBH/Class/HID/: usbh_hid.c usbh_hidparser.c
    ../../../../../../middleware/usb/uC-USBH/Class/MSC/: usbh_msc.c
    ../../../../../../middleware/lwip/contrib/ports/cmsis_os2/: sys_arch.c netdev.c net_tool.c
    ../../../../../../middleware/lwip/src/apps/lwiperf/: lwiperf.c
    ../../../../../../middleware/lwip/src/apps/tftp/: tftp.c
    ../../../../../../middleware/lwip/src/core/: init.c def.c dns.c inet_chksum.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c altcp.c altcp_alloc.c altcp_tcp.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4_frag.c ip4.c ip4_addr.c
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../middleware/lwip/src/netif/: ethernet.c
    ../../../../../../middleware/lwip/contrib/apps/ping/: ping.c
  group lib
    ../../../../../../lib/buffqueue/: buffqueue.c
    ../../../../../../lib/checksum/: adler32.c crc4.c crc16.c crc32.c md5.c
    ../../../../../../lib/debug/: debug.c errno.c
    ../../../../../../lib/disk/: disk_api.c disk_mmc.c disk_norflash.c disk_usb.c
    ../../../../../../lib/libc/iar/: io.c malloc.c
    ../../../../../../lib/partition/: partition_parser.c ab_partition_parser.c partition_disk_io.c
    ../../../../../../lib/sd_boot_img/: sd_boot_img.c
  group arch
    ../../../../../../arch/arm/armv7-r/: arm_arch.c arm_irq.c arm_fpu.c arm_mpu.c arm_faults.c
    ../../../../../../arch/arm/armv7-r/iar/: arm_atomic.S arm_start.S arm_cache.S arm_tcm.S arm_exceptions.S arm_saveusercontext.S arm_fullcontextrestore.S arm_switchcontext.S
  group boards
    ../../../../../../boards/: board.c
    ../../../../../../boards/d3_gateway/build/ref/iar/sf/configs/: core_shm_cfg.c hwmutex_cfg.c rpmsg_service_cfg.c mmc_cfg.c ram_cfg.c fee_cfg.c eth_cfg.c clock_cfg_od.c sbc_cfg.c dma_cfg.c clock_cfg_nd.c scr_cfg.c rtc_cfg.c can_cfg.c cpufreq_cfg.c reboot_cfg.c sent_cfg.c timer_cfg.c i2c_cfg.c i2s_cfg.c adc_cfg.c pwm_cfg.c mpu_cfg.c pinmux_cfg.c norflash_cfg.c codec_cfg.c pdm_cfg.c mbox_cfg.c uart_cfg.c pmu_cfg.c lin_cfg.c smc_cfg.c pinmux.c rstgen_cfg.c
    ../../../../../../boards/d3_gateway/sf/: sf_board.c
    ../../../../../../boards/d3_gateway/sf/projects/ref/: main.c
  group drivers
    ../../../../../../drivers/: adc.c can.c clk.c dma.c gpio.c hwmutex.c i2c.c irq.c lin.c mbox.c pm.c pwm.c reset.c rtc.c scr.c sent.c snd_driver.c spi_nor.c spi.c timer.c arch_timer.c uart.c watchdog.c
    ../../../../../../drivers/taishan/acmp/: sdrv_acmp_drv.c
    ../../../../../../drivers/taishan/adc/: taishan_adc.c
    ../../../../../../drivers/taishan/btm/: sdrv_btm.c sdrv_btm_drv.c
    ../../../../../../drivers/taishan/can/: flexcan_driver.c flexcan_lld.c
    ../../../../../../drivers/taishan/clk/: taishan_ckgen_drv.c taishan_ckgen.c taishan_pll_drv.c taishan_pll.c
    ../../../../../../drivers/taishan/crypto/osr_crypto/: osr_crypto_init.c
    ../../../../../../drivers/taishan/crypto/osr_crypto/cacc/ral/: hash_basic.c pke_prime.c pke.c ske_basic.c trng.c eccp_curve.c utility.c
    ../../../../../../drivers/taishan/crypto/osr_crypto/mailbox/: cmd_basic_mgmt.c cmd_eccp.c cmd_hmac.c cmd_ske_basic.c cmd_ske_mac.c cmd_sm2.c cmd_common.c cmd_hash.c cmd_rsa.c cmd_ske_gcm.c cmd_ske_xts.c cmd_sm9.c cmd_trng.c soc_otp_key.c
    ../../../../../../drivers/taishan/dma/: sdrv_dma.c sdrv_dmac.c
    ../../../../../../drivers/taishan/epwm/: sdrv_epwm.c sdrv_epwm_drv.c
    ../../../../../../drivers/taishan/eth/: dwc_eth.c dw_mac_lld.c
    ../../../../../../drivers/taishan/eth/phy/: phy.c dp83848.c rtl9010.c
    ../../../../../../drivers/taishan/etimer/: sdrv_etimer.c etimer_tmr_drv.c
    ../../../../../../drivers/taishan/fuse/: fuse.c
    ../../../../../../drivers/taishan/gpio/: taishan_gpio.c
    ../../../../../../drivers/taishan/hwmutex/: taishan_hwmutex.c
    ../../../../../../drivers/taishan/i2c/: sdrv_i2c_drv.c sdrv_i2c.c
    ../../../../../../drivers/taishan/lin/: sdrv_lin_drv.c
    ../../../../../../drivers/taishan/mbox/: sdrv_taishan_mbox_drv.c sdrv_mbox.c
    ../../../../../../drivers/taishan/mmc/core/: mmc_sdhci.c
    ../../../../../../drivers/taishan/mmc/host/: sdhci.c mmc_sehc.c
    ../../../../../../drivers/taishan/pinctrl/: taishan_pinctrl.c taishan_pinctrl_is.c
    ../../../../../../drivers/taishan/pmu/: sdrv_pmu_drv.c sdrv_pmu.c
    ../../../../../../drivers/taishan/power/: taishan_pm.c taishan_idle.c lp_utils.c
    ../../../../../../drivers/taishan/reset/: taishan_reset_drv.c taishan_rstgen.c
    ../../../../../../drivers/taishan/rtc/: sec_rtc.c sec_rtcd.c
    ../../../../../../drivers/taishan/scr/: scr_lld.c
    ../../../../../../drivers/taishan/sem/: sdrv_sem.c sdrv_sem_drv.c
    ../../../../../../drivers/taishan/sensor/: taishan_pvt.c
    ../../../../../../drivers/taishan/sent/: sdrv_sent_drv.c
    ../../../../../../drivers/taishan/smc/: sdrv_smc.c sdrv_smc_drv.c
    ../../../../../../drivers/taishan/snd/i2s/: sdrv_saci_i2s.c
    ../../../../../../drivers/taishan/snd/pdm/: sdrv_saci_pdm.c
    ../../../../../../drivers/taishan/snd/: codec_driver.c
    ../../../../../../drivers/taishan/snd/codecs/: tlv320.c
    ../../../../../../drivers/taishan/spi/: sdrv_spi.c spi_lld.c taishan_ip_spi.c
    ../../../../../../drivers/taishan/spi_nor/: taishan_xspi.c taishan_xspi_drv.c
    ../../../../../../drivers/taishan/tmonitor/: tamper_monitor.c
    ../../../../../../drivers/taishan/uart/: sdrv_uart_drv.c sdrv_uart.c
    ../../../../../../drivers/taishan/vic/: sdrv_vic.c
    ../../../../../../drivers/taishan/watchdog/: sdrv_watchdog_drv.c sdrv_watchdog.c
    ../../../../../../drivers/taishan/xtrg/: sdrv_xtrg.c sdrv_xtrg_drv.c
