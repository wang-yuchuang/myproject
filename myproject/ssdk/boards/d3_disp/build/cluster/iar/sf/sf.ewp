# IAR project sf.ewp, settings and files
configuration cluster (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCDefines: CONFIG_IARLIB
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.PreInclude: ..\..\..\..\sf\projects\cluster\config.h
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\boards\d3_disp\build\cluster\iar\sf; ..\..\..\..\..\..\.\include; ..\..\..\..\..\..\arch\arm\include; ..\..\..\..\..\..\drivers; ..\..\..\..\..\..\boards\include; ..\..\..\..\..\..\boards\d3_disp\build\cluster\iar\sf\configs; ..\..\..\..\..\..\boards\configs\include; ..\..\..\..\..\..\arch\arm\armv7-r\include; ..\..\..\..\..\..\arch\arm\d3; ..\..\..\..\..\..\boards\d3_disp\sf; ..\..\..\..\..\..\boards\d3_disp\sf\include; ..\..\..\..\..\..\lib\checksum\include; ..\..\..\..\..\..\lib\debug\include; ..\..\..\..\..\..\lib\disk\include; ..\..\..\..\..\..\lib\libc\iar\include; ..\..\..\..\..\..\lib\partition\include; ..\..\..\..\..\..\lib\sd_boot_img\include; ..\..\..\..\..\..\middleware\CLI\include; ..\..\..\..\..\..\middleware\coremark\include; ..\..\..\..\..\..\middleware\dhrystone\include; ..\..\..\..\..\..\middleware\fatfs\include; ..\..\..\..\..\..\middleware\fatfs\include; ..\..\..\..\..\..\middleware\flops\include; ..\..\..\..\..\..\middleware\gpu_hal; ..\..\..\..\..\..\middleware\gpu_hal\inc; ..\..\..\..\..\..\middleware\gpu_hal\include; ..\..\..\..\..\..\middleware\littlevgl; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7; ..\..\..\..\..\..\middleware\littlevgl\lvgl_sdrv; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_core; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_hal; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_widgets; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_font; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_misc; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_themes; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_draw; ..\..\..\..\..\..\middleware\littlevgl\lvgl-release-v7\src\lv_gpu; ..\..\..\..\..\..\middleware\littlevgl\lvgl_sdrv\display; ..\..\..\..\..\..\middleware\littlevgl\lvgl_sdrv\decoder\lodepng; ..\..\..\..\..\..\middleware\littlevgl\lvgl_sdrv\fs; ..\..\..\..\..\..\middleware\littlevgl\lvgl_sdrv\gpu; ..\..\..\..\..\..\middleware\littlevgl\lvgl_sdrv\input; ..\..\..\..\..\..\middleware\littlevgl\include; ..\..\..\..\..\..\middleware\lodepng; ..\..\..\..\..\..\middleware\lodepng\inc; ..\..\..\..\..\..\middleware\lodepng\include; ..\..\..\..\..\..\middleware\mem_rw\include; ..\..\..\..\..\..\middleware\minimp3\include; ..\..\..\..\..\..\middleware\minimp3\include; ..\..\..\..\..\..\middleware\mjpeg; ..\..\..\..\..\..\middleware\mjpeg\include; ..\..\..\..\..\..\middleware\reboot; ..\..\..\..\..\..\middleware\reboot\include; ..\..\..\..\..\..\middleware\tjpgdec; ..\..\..\..\..\..\middleware\tjpgdec\include; ..\..\..\..\..\..\middleware\usb\include; ..\..\..\..\..\..\middleware\usb\include; ..\..\..\..\..\..\rtos\FreeRTOS\include; ..\..\..\..\..\..\drivers\taishan\acmp; ..\..\..\..\..\..\drivers\taishan\acmp\include; ..\..\..\..\..\..\drivers\taishan\adc\include; ..\..\..\..\..\..\drivers\taishan\btm; ..\..\..\..\..\..\drivers\taishan\btm\include; ..\..\..\..\..\..\drivers\taishan\can\include; ..\..\..\..\..\..\drivers\taishan\clk; ..\..\..\..\..\..\drivers\taishan\clk\include; ..\..\..\..\..\..\drivers\taishan\crypto\osr_crypto\; ..\..\..\..\..\..\drivers\taishan\crypto\osr_crypto\cacc\; ..\..\..\..\..\..\drivers\taishan\crypto\osr_crypto\include; ..\..\..\..\..\..\drivers\taishan\csi\include; ..\..\..\..\..\..\drivers\taishan\dispss\include; ..\..\..\..\..\..\drivers\taishan\dma\include; ..\..\..\..\..\..\drivers\taishan\epwm; ..\..\..\..\..\..\drivers\taishan\epwm\include; ..\..\..\..\..\..\drivers\taishan\eth\include; ..\..\..\..\..\..\drivers\taishan\etimer; ..\..\..\..\..\..\drivers\taishan\etimer\include; ..\..\..\..\..\..\drivers\taishan\fuse\include; ..\..\..\..\..\..\drivers\taishan\g2dlite\include; ..\..\..\..\..\..\drivers\taishan\gpio\include; ..\..\..\..\..\..\drivers\taishan\hwmutex\include; ..\..\..\..\..\..\drivers\taishan\i2c\include; ..\..\..\..\..\..\drivers\taishan\mbox\include; ..\..\..\..\..\..\drivers\taishan\mmc\include; ..\..\..\..\..\..\drivers\taishan\pinctrl\include; ..\..\..\..\..\..\drivers\taishan\pmu; ..\..\..\..\..\..\drivers\taishan\pmu\include; ..\..\..\..\..\..\drivers\taishan\power\include; ..\..\..\..\..\..\drivers\taishan\reset\include; ..\..\..\..\..\..\drivers\taishan\rtc\include; ..\..\..\..\..\..\drivers\taishan\scr\include; ..\..\..\..\..\..\drivers\taishan\sdramc\include; ..\..\..\..\..\..\drivers\taishan\sem; ..\..\..\..\..\..\drivers\taishan\sem\include; ..\..\..\..\..\..\drivers\taishan\sensor\include; ..\..\..\..\..\..\drivers\taishan\smc\include; ..\..\..\..\..\..\drivers\taishan\snd\include; ..\..\..\..\..\..\drivers\taishan\spi; ..\..\..\..\..\..\drivers\taishan\spi\include; ..\..\..\..\..\..\drivers\taishan\spi_nor\include; ..\..\..\..\..\..\drivers\taishan\touch\include; ..\..\..\..\..\..\drivers\taishan\uart; ..\..\..\..\..\..\drivers\taishan\uart\include; ..\..\..\..\..\..\drivers\taishan\vic\include; ..\..\..\..\..\..\drivers\taishan\watchdog\include; ..\..\..\..\..\..\drivers\taishan\xtrg; ..\..\..\..\..\..\drivers\taishan\xtrg\include; ..\..\..\..\..\..\examples\taishan\ota\inc; ..\..\..\..\..\..\examples\taishan\ota\include; ..\..\..\..\..\..\middleware\usb\uC-USBD; ..\..\..\..\..\..\middleware\usb\uC-USBD\include; ..\..\..\..\..\..\middleware\usb\uC-USBH; ..\..\..\..\..\..\middleware\usb\uC-USBH\include; ..\..\..\..\..\..\examples\taishan\application\bootanimation; ..\..\..\..\..\..\examples\taishan\application\bootanimation\inc; ..\..\..\..\..\..\examples\taishan\application\bootanimation\include; ..\..\..\..\..\..\examples\taishan\application\cluster; ..\..\..\..\..\..\examples\taishan\application\cluster\inc; ..\..\..\..\..\..\middleware\sd_graphics\inc; ..\..\..\..\..\..\examples\taishan\application\cluster\include; ..\..\..\..\..\..\examples\taishan\application\launcher; ..\..\..\..\..\..\examples\taishan\application\launcher\inc; ..\..\..\..\..\..\examples\taishan\application\launcher\include; ..\..\..\..\..\..\examples\taishan\application\mjpeg_dec\include; ..\..\..\..\..\..\examples\taishan\application\mp3_dec\include; ..\..\..\..\..\..\examples\taishan\boot\global_reboot\include; ..\..\..\..\..\..\examples\taishan\drivers\acmp\include; ..\..\..\..\..\..\examples\taishan\drivers\adc\include; ..\..\..\..\..\..\examples\taishan\drivers\analog_in\include; ..\..\..\..\..\..\examples\taishan\drivers\canfd\include; ..\..\..\..\..\..\examples\taishan\drivers\dma\include; ..\..\..\..\..\..\examples\taishan\drivers\led\include; ..\..\..\..\..\..\examples\taishan\drivers\pmu\include; ..\..\..\..\..\..\examples\taishan\drivers\watchdog\include; ..\..\..\..\..\..\examples\taishan\util\gating\include; ..\..\..\..\..\..\examples\taishan\util\power_monitor\include; ..\..\..\..\..\..\examples\taishan\util\pvt\include; ..\..\..\..\..\..\middleware\lwip\src\include; ..\..\..\..\..\..\middleware\lwip\contrib\ports\cmsis_os2\include; ..\..\..\..\..\..\middleware\lwip\contrib; ..\..\..\..\..\..\middleware\lwip\include; ..\..\..\..\..\..\examples\taishan\drivers\usb\USBD_Serial\include; ..\..\..\..\..\..\arch\arm\armv7-r; ..\..\..\..\..\..\middleware\coremark\ssdk; ..\..\..\..\..\..\middleware\coremark; ..\..\..\..\..\..\rtos\FreeRTOS\Config; ..\..\..\..\..\..\rtos\FreeRTOS\Source\include; ..\..\..\..\..\..\rtos\FreeRTOS\Source\portable\IAR\ARM_CR5; ..\..\..\..\..\..\include\driver\pinctrl; ..\..\..\..\..\..\include\driver\gpio; ..\..\..\..\..\..\drivers\taishan\csi\excam; ..\..\..\..\..\..\drivers\taishan\csi\csi_drv; ..\..\..\..\..\..\drivers\taishan\csi\cam_hal; ..\..\..\..\..\..\include\driver\taishan\spi\; ..\..\..\..\sf\projects\cluster; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: ASSEMBLY; __ICCARM__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sf.bin
  prebuild: ..\..\..\..\..\..\tools\iarprebuild.bat d3_disp cluster sf ..\..\..\..\..\..
  postbuild: ..\..\..\..\..\..\tools\sdtools\package.bat d3_disp cluster
  ILINK.IlinkOutputFile: sf.out
  ILINK.IlinkIcfFile: ..\..\..\..\sf\scripts\iar\sdram.icf
  ILINK.IlinkExtraOptions: --config_def; MEMBASE=0x404000; --config_def; MEMSIZE=0x3FC000; --config_def; TCMBASE=0x1900000; --config_def; TCMSIZE=0x20000; --config_def; NONEECCBASE=0x800000; --config_def; NONEECCSIZE=0; --config_def; SDRAMBASE=0x30000000; --config_def; SDRAMSIZE=0x4000000
  ILINK.IlinkProgramEntryLabel: _start
  group arch
    ../../../../../../arch/arm/armv7-r/: arm_arch.c arm_faults.c arm_fpu.c arm_irq.c arm_mpu.c
    ../../../../../../arch/arm/armv7-r/iar/: arm_atomic.S arm_cache.S arm_exceptions.S arm_fullcontextrestore.S arm_saveusercontext.S arm_start.S arm_switchcontext.S arm_tcm.S
  group boards
    configs/: adc_cfg.c asw_cfg.c cam_cfg.c can_cfg.c clock_cfg_nd.c clock_cfg_od.c codec_cfg.c cpufreq_cfg.c dispss_cfg.c dma_cfg.c eth_cfg.c fee_cfg.c g2dlite_cfg.c i2c_cfg.c i2s_cfg.c mbox_cfg.c mmc_cfg.c mpu_cfg.c norflash_cfg.c pdm_cfg.c pinmux.c pinmux_cfg.c pinmux_cfg_z1.c pmu_cfg.c pwm_cfg.c ram_cfg.c remap_cfg.c rstgen_cfg.c rtc_cfg.c scr_cfg.c sdramc_cfg.c smc_cfg.c timer_cfg.c touch_cfg.c uart_cfg.c
    ../../../../../: board.c
    ../../../../sf/projects/cluster/: main.c
    ../../../../sf/: sf_board.c
  group drivers
    ../../../../../../drivers/: adc.c arch_timer.c can.c clk.c dma.c gpio.c hwmutex.c i2c.c irq.c mbox.c pm.c pwm.c reset.c rtc.c scr.c snd_driver.c spi.c spi_nor.c timer.c uart.c watchdog.c
    ../../../../../../drivers/taishan/snd/codecs/: ak4619.c
    ../../../../../../drivers/taishan/csi/cam_hal/: cam_hal.c
    ../../../../../../drivers/taishan/crypto/osr_crypto/mailbox/: cmd_basic_mgmt.c cmd_common.c cmd_eccp.c cmd_hash.c cmd_hmac.c cmd_rsa.c cmd_ske_basic.c cmd_ske_gcm.c cmd_ske_mac.c cmd_ske_xts.c cmd_sm2.c cmd_sm9.c cmd_trng.c soc_otp_key.c
    ../../../../../../drivers/taishan/snd/: codec_driver.c
    ../../../../../../drivers/taishan/csi/csi_drv/: csi_drv.c csi_hw.c
    ../../../../../../drivers/taishan/eth/phy/: dp83848.c phy.c rtl9010.c
    ../../../../../../drivers/taishan/eth/: dw_mac_lld.c dwc_eth.c
    ../../../../../../drivers/taishan/crypto/osr_crypto/cacc/ral/: eccp_curve.c hash_basic.c pke.c pke_prime.c ske_basic.c trng.c utility.c
    ../../../../../../drivers/taishan/etimer/: etimer_pwm_drv.c etimer_tmr_drv.c sdrv_etimer.c
    ../../../../../../drivers/taishan/csi/excam/: ex_max96706.c
    ../../../../../../drivers/taishan/can/: flexcan_driver.c flexcan_lld.c
    ../../../../../../drivers/taishan/fuse/: fuse.c
    ../../../../../../drivers/taishan/touch/: goodix.c touch_core.c touch_event.c
    ../../../../../../drivers/taishan/power/: lp_utils.c taishan_idle.c taishan_pm.c
    ../../../../../../drivers/taishan/dispss/lcm/: lvds_1440x540_lcd.c sdrv_panels.c
    ../../../../../../drivers/taishan/mmc/core/: mmc_sdhci.c
    ../../../../../../drivers/taishan/mmc/host/: mmc_sehc.c sdhci.c
    ../../../../../../drivers/taishan/crypto/osr_crypto/: osr_crypto_init.c
    ../../../../../../drivers/taishan/scr/: scr_lld.c
    ../../../../../../drivers/taishan/acmp/: sdrv_acmp_drv.c
    ../../../../../../drivers/taishan/btm/: sdrv_btm.c sdrv_btm_drv.c
    ../../../../../../drivers/taishan/dispss/: sdrv_dispss.c
    ../../../../../../drivers/taishan/dma/: sdrv_dma.c sdrv_dmac.c
    ../../../../../../drivers/taishan/epwm/: sdrv_epwm.c sdrv_epwm_drv.c
    ../../../../../../drivers/taishan/g2dlite/: sdrv_g2dlite.c
    ../../../../../../drivers/taishan/i2c/: sdrv_i2c.c sdrv_i2c_drv.c
    ../../../../../../drivers/taishan/mbox/: sdrv_mbox.c sdrv_taishan_mbox_drv.c
    ../../../../../../drivers/taishan/pmu/: sdrv_pmu.c sdrv_pmu_drv.c
    ../../../../../../drivers/taishan/snd/i2s/: sdrv_saci_i2s.c
    ../../../../../../drivers/taishan/snd/pdm/: sdrv_saci_pdm.c
    ../../../../../../drivers/taishan/sem/: sdrv_sem.c sdrv_sem_drv.c
    ../../../../../../drivers/taishan/smc/: sdrv_smc.c sdrv_smc_drv.c
    ../../../../../../drivers/taishan/spi/: sdrv_spi.c spi_lld.c taishan_ip_spi.c
    ../../../../../../drivers/taishan/uart/: sdrv_uart.c sdrv_uart_drv.c
    ../../../../../../drivers/taishan/vic/: sdrv_vic.c
    ../../../../../../drivers/taishan/watchdog/: sdrv_watchdog.c sdrv_watchdog_drv.c
    ../../../../../../drivers/taishan/xtrg/: sdrv_xtrg.c sdrv_xtrg_drv.c
    ../../../../../../drivers/taishan/rtc/: sec_rtc.c sec_rtcd.c
    ../../../../../../drivers/taishan/adc/: taishan_adc.c
    ../../../../../../drivers/taishan/clk/: taishan_ckgen.c taishan_ckgen_drv.c taishan_pll.c taishan_pll_drv.c
    ../../../../../../drivers/taishan/gpio/: taishan_gpio.c
    ../../../../../../drivers/taishan/hwmutex/: taishan_hwmutex.c
    ../../../../../../drivers/taishan/pinctrl/: taishan_pinctrl.c taishan_pinctrl_is.c
    ../../../../../../drivers/taishan/sensor/: taishan_pvt.c
    ../../../../../../drivers/taishan/reset/: taishan_reset_drv.c taishan_rstgen.c
    ../../../../../../drivers/taishan/sdramc/: taishan_sdramc.c
    ../../../../../../drivers/taishan/spi_nor/: taishan_xspi.c taishan_xspi_drv.c
  group examples
    ../../../../../../examples/taishan/drivers/acmp/: acmp_test.c
    ../../../../../../examples/taishan/drivers/analog_in/: analog_in_demo.c
    ../../../../../../examples/taishan/application/bootanimation/src/: animation.c decoder.c player.c render.c
    ../../../../../../examples/taishan/drivers/dma/: app_dma.c
    ../../../../../../examples/taishan/drivers/usb/USBD_Serial/: app_usbd.c app_usbd_cdc.c
    ../../../../../../examples/taishan/drivers/canfd/: can_demo.c
    ../../../../../../examples/taishan/util/gating/: clk_gate_d3.c power_gate_d3.c
    ../../../../../../examples/taishan/application/mjpeg_dec/: cluster_bin.c mjpeg_test.c
    ../../../../../../examples/taishan/boot/global_reboot/: global_reboot.c
    ../../../../../../examples/taishan/application/launcher/src/: launcher.c
    ../../../../../../examples/taishan/drivers/led/: led_demo.c
    ../../../../../../examples/taishan/application/cluster/src/: lv_demo_cluster.c
    ../../../../../../examples/taishan/application/mp3_dec/: mp3_player.c
    ../../../../../../examples/taishan/ota/: ota.c ota_eth.c
    ../../../../../../examples/taishan/util/power_monitor/: power_monitor.c power_monitor_d3_disp.c
    ../../../../../../examples/taishan/drivers/adc/: taishan_adc_test.c
    ../../../../../../examples/taishan/drivers/pmu/: taishan_pmu_demo.c
    ../../../../../../examples/taishan/util/pvt/: taishan_pvt_example.c
    ../../../../../../examples/taishan/drivers/watchdog/: watchdog_demo.c
  group lib
    ../../../../../../lib/partition/: ab_partition_parser.c partition_disk_io.c partition_parser.c
    ../../../../../../lib/checksum/: adler32.c crc16.c crc32.c crc4.c md5.c
    ../../../../../../lib/debug/: debug.c errno.c
    ../../../../../../lib/disk/: disk_api.c disk_mmc.c disk_norflash.c disk_usb.c
    ../../../../../../lib/libc/iar/: io.c malloc.c
    ../../../../../../lib/sd_boot_img/: sd_boot_img.c
  group middleware
    ../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../../middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../middleware/CLI/: CLI.c CLI_console.c CLI_task.c
    ../../../../../../middleware/coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
    ../../../../../../middleware/coremark/ssdk/: core_portme.c
    ../../../../../../middleware/dhrystone/v2.1/: dhry.c dhry_1.c dhry_2.c
    ../../../../../../middleware/fatfs/: diskio_sdrv.c ff.c ff_unittest.c ffsystem.c ffunicode.c
    ../../../../../../middleware/lwip/src/netif/: ethernet.c
    ../../../../../../middleware/littlevgl/lvgl_sdrv/fs/: fatfs_semidrive.c
    ../../../../../../middleware/flops/: flops.c flops_main.c linpack.c whetstone.c
    ../../../../../../middleware/gpu_hal/src/: gpu_hal.c
    ../../../../../../middleware/usb/: lib_mem.c usb_bsp_e3.c
    ../../../../../../middleware/lodepng/src/: lodepng.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_page.c lv_rear_guide_line.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_unscii_8.c
    ../../../../../../middleware/littlevgl/lvgl_sdrv/gpu/: lv_gpu_sdrv_dma2d.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_gpu/: lv_gpu_stm32_dma2d.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../../../../middleware/littlevgl/lvgl_sdrv/decoder/lodepng/: lv_png.c
    ../../../../../../middleware/littlevgl/lvgl_sdrv/input/: lv_port_indev.c
    ../../../../../../middleware/littlevgl/lvgl-release-v7/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../../../../../../middleware/littlevgl/lvgl_sdrv/display/: lvgl_disp_drv.c
    ../../../../../../middleware/littlevgl/lvgl_sdrv/: lvgl_gui.c
    ../../../../../../middleware/lwip/src/apps/lwiperf/: lwiperf.c
    ../../../../../../middleware/mem_rw/: mem_rw.c
    ../../../../../../middleware/minimp3/: minimp3.c
    ../../../../../../middleware/mjpeg/: mjpeg.c
    ../../../../../../middleware/lwip/contrib/ports/cmsis_os2/: net_tool.c netdev.c sys_arch.c
    ../../../../../../middleware/lwip/contrib/apps/ping/: ping.c
    ../../../../../../middleware/reboot/: reboot_taishan_global.c
    ../../../../../../middleware/lwip/src/apps/tftp/: tftp.c
    ../../../../../../middleware/tjpgdec/: tjpgd.c
    ../../../../../../middleware/usb/uC-USBD/Class/CDC/ACM/: usbd_acm_serial.c
    ../../../../../../middleware/usb/uC-USBD/Class/CDC/: usbd_cdc.c
    ../../../../../../middleware/usb/uC-USBD/Source/: usbd_core.c usbd_ep.c
    ../../../../../../middleware/usb/uC-USBD/Drivers/drv_lib/: usbd_drv_lib.c
    ../../../../../../middleware/usb/uC-USBD/Drivers/Renesas_USBHS/: usbd_drv_renesas_usbhs.c
    ../../../../../../middleware/usb/uC-USBD/OS/cmsis_os/: usbd_os.c
    ../../../../../../middleware/usb/uC-USBH/Source/: usbh_class.c usbh_core.c usbh_hub.c
    ../../../../../../middleware/usb/uC-USBH/HCD/EHCI/: usbh_hcd_ehci.c
    ../../../../../../middleware/usb/uC-USBH/HCD/OHCI/: usbh_hcd_ohci.c
    ../../../../../../middleware/usb/uC-USBH/Class/HID/: usbh_hid.c usbh_hidparser.c
    ../../../../../../middleware/usb/uC-USBH/Class/MSC/: usbh_msc.c
    ../../../../../../middleware/usb/uC-USBH/OS/cmsis_os/: usbh_os.c
  group rtos
    ../../../../../../rtos/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../rtos/FreeRTOS/Source/portable/CMSIS/: freertos_cmsis.c
    ../../../../../../rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../rtos/FreeRTOS/Source/portable/Common/: irq_wrapper.c timer_wrapper.c
    ../../../../../../rtos/FreeRTOS/Source/portable/IAR/ARM_CR5/: port.c portASM.S
  group usrlibs
    ../../../../../../drivers/taishan/dispss/libs/: libdispss.a
    ../../../../../../drivers/taishan/g2dlite/libs/: libg2dlite.a
    ../../../../../../middleware/sd_graphics/: libsd_graphics.a
