# IAR project sf.ewp, settings and files
configuration baremetal (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCDefines: CONFIG_IARLIB
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.PreInclude: ..\..\..\..\sf\projects\baremetal\config.h
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\boards\d3_gateway\build\baremetal\iar\sf; ..\..\..\..\..\..\.\include; ..\..\..\..\..\..\arch\arm\include; ..\..\..\..\..\..\drivers; ..\..\..\..\..\..\boards\include; ..\..\..\..\..\..\boards\d3_gateway\build\baremetal\iar\sf\configs; ..\..\..\..\..\..\boards\configs\include; ..\..\..\..\..\..\arch\arm\armv7-r\include; ..\..\..\..\..\..\arch\arm\d3; ..\..\..\..\..\..\boards\d3_gateway\sf; ..\..\..\..\..\..\boards\d3_gateway\sf\include; ..\..\..\..\..\..\lib\buffqueue\include; ..\..\..\..\..\..\lib\checksum\include; ..\..\..\..\..\..\lib\debug\include; ..\..\..\..\..\..\lib\disk\include; ..\..\..\..\..\..\lib\libc\iar\include; ..\..\..\..\..\..\lib\partition\include; ..\..\..\..\..\..\lib\sd_boot_img\include; ..\..\..\..\..\..\middleware\CLI\include; ..\..\..\..\..\..\middleware\mem_rw\include; ..\..\..\..\..\..\rtos\BareMetal\include; ..\..\..\..\..\..\drivers\taishan\btm; ..\..\..\..\..\..\drivers\taishan\btm\include; ..\..\..\..\..\..\drivers\taishan\clk; ..\..\..\..\..\..\drivers\taishan\clk\include; ..\..\..\..\..\..\drivers\taishan\gpio\include; ..\..\..\..\..\..\drivers\taishan\pinctrl\include; ..\..\..\..\..\..\drivers\taishan\reset\include; ..\..\..\..\..\..\drivers\taishan\scr\include; ..\..\..\..\..\..\drivers\taishan\uart; ..\..\..\..\..\..\drivers\taishan\uart\include; ..\..\..\..\..\..\drivers\taishan\vic\include; ..\..\..\..\..\..\arch\arm\armv7-r; ..\..\..\..\sf\projects\baremetal; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: ASSEMBLY; __ICCARM__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sf.bin
  prebuild: ..\..\..\..\..\..\tools\iarprebuild.bat d3_gateway baremetal sf ..\..\..\..\..\..
  postbuild: ..\..\..\..\..\..\tools\sdtools\package.bat d3_gateway baremetal
  ILINK.IlinkOutputFile: sf.out
  ILINK.IlinkIcfFile: ..\..\..\..\sf\scripts\iar\ram.icf
  ILINK.IlinkExtraOptions: --config_def; MEMBASE=0x404000; --config_def; MEMSIZE=0x1F4000; --config_def; TCMBASE=0x1900000; --config_def; TCMSIZE=0x20000; --config_def; NONEECCBASE=0x800000; --config_def; NONEECCSIZE=0
  ILINK.IlinkProgramEntryLabel: _start
  group rtos
    ../../../../../../rtos/BareMetal/IAR/ARM_CR5/: exceptions.S
    ../../../../../../rtos/BareMetal/: irq_wrapper.c baremetal_cmsis.c
  group middleware
    ../../../../../../middleware/CLI/: CLI.c CLI_console.c CLI_task.c
    ../../../../../../middleware/mem_rw/: mem_rw.c
  group lib
    ../../../../../../lib/buffqueue/: buffqueue.c
    ../../../../../../lib/checksum/: adler32.c crc4.c crc16.c crc32.c md5.c
    ../../../../../../lib/debug/: debug.c errno.c
    ../../../../../../lib/disk/: disk_api.c disk_mmc.c disk_norflash.c
    ../../../../../../lib/libc/iar/: io.c
    ../../../../../../lib/partition/: partition_parser.c ab_partition_parser.c partition_disk_io.c
    ../../../../../../lib/sd_boot_img/: sd_boot_img.c
  group arch
    ../../../../../../arch/arm/armv7-r/: arm_arch.c arm_irq.c arm_fpu.c arm_mpu.c arm_faults.c
    ../../../../../../arch/arm/armv7-r/iar/: arm_atomic.S arm_start.S arm_cache.S arm_tcm.S arm_exceptions.S arm_saveusercontext.S arm_fullcontextrestore.S arm_switchcontext.S
  group boards
    ../../../../../../boards/: board.c
    ../../../../../../boards/d3_gateway/build/baremetal/iar/sf/configs/: pinmux_cfg.c uart_cfg.c pwm_cfg.c core_shm_cfg.c hwmutex_cfg.c rpmsg_service_cfg.c mmc_cfg.c ram_cfg.c fee_cfg.c eth_cfg.c clock_cfg_od.c sbc_cfg.c dma_cfg.c clock_cfg_nd.c scr_cfg.c rtc_cfg.c can_cfg.c cpufreq_cfg.c reboot_cfg.c sent_cfg.c timer_cfg.c i2c_cfg.c i2s_cfg.c adc_cfg.c mpu_cfg.c norflash_cfg.c codec_cfg.c pdm_cfg.c mbox_cfg.c pmu_cfg.c lin_cfg.c smc_cfg.c pinmux.c rstgen_cfg.c
    ../../../../../../boards/d3_gateway/sf/: sf_board.c
    ../../../../../../boards/d3_gateway/sf/projects/baremetal/: main.c
  group drivers
    ../../../../../../drivers/: clk.c gpio.c irq.c reset.c scr.c timer.c arch_timer.c uart.c
    ../../../../../../drivers/taishan/btm/: sdrv_btm.c sdrv_btm_drv.c
    ../../../../../../drivers/taishan/clk/: taishan_ckgen_drv.c taishan_ckgen.c taishan_pll_drv.c taishan_pll.c
    ../../../../../../drivers/taishan/gpio/: taishan_gpio.c
    ../../../../../../drivers/taishan/pinctrl/: taishan_pinctrl.c taishan_pinctrl_is.c
    ../../../../../../drivers/taishan/reset/: taishan_reset_drv.c taishan_rstgen.c
    ../../../../../../drivers/taishan/scr/: scr_lld.c
    ../../../../../../drivers/taishan/uart/: sdrv_uart_drv.c sdrv_uart.c
    ../../../../../../drivers/taishan/vic/: sdrv_vic.c
