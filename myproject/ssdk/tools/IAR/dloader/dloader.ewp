# IAR project dloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: e3_dloader.srec
  ILINK.IlinkOutputFile: dloader.out
  ILINK.IlinkIcfFile: dloader.icf
  ILINK.IlinkExtraOptions: --image_input E:\code\ssdk\tools\IAR\dloader\bin\sfs.img,SFS_BIN,SFS_BIN,8; --keep SFS_BIN; --image_input E:\code\ssdk\tools\IAR\dloader\bin\boot0.img,BOOT0_BIN,BOOT0_BIN,8; --keep BOOT0_BIN; --image_input E:\code\ssdk\tools\IAR\dloader\bin\boot1.img,BOOT1_BIN,BOOT1_BIN,8; --keep BOOT1_BIN; --image_input E:\code\ssdk\tools\IAR\dloader\bin\boot2.img,BOOT2_BIN,BOOT2_BIN,8; --keep BOOT2_BIN
  ILINK.IlinkProgramEntryLabel: SFS_BIN
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
