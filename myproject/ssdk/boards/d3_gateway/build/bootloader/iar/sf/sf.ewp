# IAR project sf.ewp, settings and files
configuration bootloader (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCDefines: CONFIG_IARLIB
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.PreInclude: ..\..\..\..\sf\projects\bootloader\config.h
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\boards\d3_gateway\build\bootloader\iar\sf; ..\..\..\..\..\..\.\include; ..\..\..\..\..\..\arch\arm\include; ..\..\..\..\..\..\drivers; ..\..\..\..\..\..\boards\include; ..\..\..\..\..\..\boards\d3_gateway\build\bootloader\iar\sf\configs; ..\..\..\..\..\..\boards\configs\include; ..\..\..\..\..\..\arch\arm\armv7-r\include; ..\..\..\..\..\..\arch\arm\d3; ..\..\..\..\..\..\boards\d3_gateway\sf; ..\..\..\..\..\..\boards\d3_gateway\sf\include; ..\..\..\..\..\..\lib\buffqueue\include; ..\..\..\..\..\..\lib\checksum\include; ..\..\..\..\..\..\lib\debug\include; ..\..\..\..\..\..\lib\disk\include; ..\..\..\..\..\..\lib\libc\iar\include; ..\..\..\..\..\..\lib\partition\include; ..\..\..\..\..\..\lib\sd_boot_img\include; ..\..\..\..\..\..\middleware\CLI\include; ..\..\..\..\..\..\middleware\fatfs\include; ..\..\..\..\..\..\middleware\fatfs\include; ..\..\..\..\..\..\middleware\mem_rw\include; ..\..\..\..\..\..\middleware\reboot; ..\..\..\..\..\..\middleware\reboot\include; ..\..\..\..\..\..\rtos\FreeRTOS\include; ..\..\..\..\..\..\drivers\taishan\btm; ..\..\..\..\..\..\drivers\taishan\btm\include; ..\..\..\..\..\..\drivers\taishan\clk; ..\..\..\..\..\..\drivers\taishan\clk\include; ..\..\..\..\..\..\drivers\taishan\eth\include; ..\..\..\..\..\..\drivers\taishan\gpio\include; ..\..\..\..\..\..\drivers\taishan\mmc\include; ..\..\..\..\..\..\drivers\taishan\pinctrl\include; ..\..\..\..\..\..\drivers\taishan\reset\include; ..\..\..\..\..\..\drivers\taishan\scr\include; ..\..\..\..\..\..\drivers\taishan\spi_nor\include; ..\..\..\..\..\..\drivers\taishan\uart; ..\..\..\..\..\..\drivers\taishan\uart\include; ..\..\..\..\..\..\drivers\taishan\vic\include; ..\..\..\..\..\..\examples\taishan\ota\inc; ..\..\..\..\..\..\examples\taishan\ota\include; ..\..\..\..\..\..\middleware\lwip\src\include; ..\..\..\..\..\..\middleware\lwip\contrib\ports\cmsis_os2\include; ..\..\..\..\..\..\middleware\lwip\contrib; ..\..\..\..\..\..\middleware\lwip\include; ..\..\..\..\..\..\arch\arm\armv7-r; ..\..\..\..\..\..\rtos\FreeRTOS\Config; ..\..\..\..\..\..\rtos\FreeRTOS\Source\include; ..\..\..\..\..\..\rtos\FreeRTOS\Source\portable\IAR\ARM_CR5; ..\..\..\..\sf\projects\bootloader; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: ASSEMBLY; __ICCARM__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sf.bin
  prebuild: ..\..\..\..\..\..\tools\iarprebuild.bat d3_gateway bootloader sf ..\..\..\..\..\..
  postbuild: ..\..\..\..\..\..\tools\sdtools\package.bat d3_gateway bootloader
  ILINK.IlinkOutputFile: sf.out
  ILINK.IlinkIcfFile: ..\..\..\..\sf\scripts\iar\ram.icf
  ILINK.IlinkExtraOptions: --config_def; MEMBASE=0x404000; --config_def; MEMSIZE=0x1F4000; --config_def; TCMBASE=0x1900000; --config_def; TCMSIZE=0x20000; --config_def; NONEECCBASE=0x800000; --config_def; NONEECCSIZE=0
  ILINK.IlinkProgramEntryLabel: _start
  group examples
    ../../../../../../examples/taishan/ota/: ota.c ota_eth.c
  group rtos
    ../../../../../../rtos/FreeRTOS/Source/portable/IAR/ARM_CR5/: portASM.S port.c
    ../../../../../../rtos/FreeRTOS/Source/portable/Common/: irq_wrapper.c timer_wrapper.c
    ../../../../../../rtos/FreeRTOS/Source/portable/CMSIS/: freertos_cmsis.c
    ../../../../../../rtos/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group middleware
    ../../../../../../middleware/CLI/: CLI.c CLI_console.c CLI_task.c
    ../../../../../../middleware/fatfs/: diskio_sdrv.c ff.c ffsystem.c ffunicode.c ff_unittest.c
    ../../../../../../middleware/mem_rw/: mem_rw.c
    ../../../../../../middleware/reboot/: reboot_taishan_global.c
    ../../../../../../middleware/lwip/contrib/ports/cmsis_os2/: sys_arch.c netdev.c net_tool.c
    ../../../../../../middleware/lwip/src/apps/lwiperf/: lwiperf.c
    ../../../../../../middleware/lwip/src/apps/tftp/: tftp.c
    ../../../../../../middleware/lwip/src/core/: init.c def.c dns.c inet_chksum.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c altcp.c altcp_alloc.c altcp_tcp.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4_frag.c ip4.c ip4_addr.c
    ../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../middleware/lwip/src/netif/: ethernet.c
    ../../../../../../middleware/lwip/contrib/apps/ping/: ping.c
  group lib
    ../../../../../../lib/buffqueue/: buffqueue.c
    ../../../../../../lib/checksum/: adler32.c crc4.c crc16.c crc32.c md5.c
    ../../../../../../lib/debug/: debug.c errno.c
    ../../../../../../lib/disk/: disk_api.c disk_mmc.c disk_norflash.c
    ../../../../../../lib/libc/iar/: io.c malloc.c
    ../../../../../../lib/partition/: partition_parser.c ab_partition_parser.c partition_disk_io.c
    ../../../../../../lib/sd_boot_img/: sd_boot_img.c
  group arch
    ../../../../../../arch/arm/armv7-r/: arm_arch.c arm_irq.c arm_fpu.c arm_mpu.c arm_faults.c
    ../../../../../../arch/arm/armv7-r/iar/: arm_atomic.S arm_start.S arm_cache.S arm_tcm.S arm_exceptions.S arm_saveusercontext.S arm_fullcontextrestore.S arm_switchcontext.S
  group boards
    ../../../../../../boards/: board.c
    ../../../../../../boards/d3_gateway/build/bootloader/iar/sf/configs/: clock_cfg_nd.c core_shm_cfg.c hwmutex_cfg.c rpmsg_service_cfg.c mmc_cfg.c ram_cfg.c fee_cfg.c eth_cfg.c clock_cfg_od.c sbc_cfg.c dma_cfg.c scr_cfg.c rtc_cfg.c can_cfg.c cpufreq_cfg.c reboot_cfg.c sent_cfg.c timer_cfg.c i2c_cfg.c i2s_cfg.c adc_cfg.c pwm_cfg.c mpu_cfg.c pinmux_cfg.c norflash_cfg.c codec_cfg.c pdm_cfg.c mbox_cfg.c uart_cfg.c pmu_cfg.c lin_cfg.c smc_cfg.c pinmux.c rstgen_cfg.c
    ../../../../../../boards/d3_gateway/sf/: sf_board.c
    ../../../../../../boards/d3_gateway/sf/projects/bootloader/: main.c
  group drivers
    ../../../../../../drivers/: clk.c gpio.c irq.c reset.c scr.c spi_nor.c timer.c arch_timer.c uart.c
    ../../../../../../drivers/taishan/btm/: sdrv_btm.c sdrv_btm_drv.c
    ../../../../../../drivers/taishan/clk/: taishan_ckgen_drv.c taishan_ckgen.c taishan_pll_drv.c taishan_pll.c
    ../../../../../../drivers/taishan/eth/: dwc_eth.c dw_mac_lld.c
    ../../../../../../drivers/taishan/eth/phy/: phy.c dp83848.c rtl9010.c
    ../../../../../../drivers/taishan/gpio/: taishan_gpio.c
    ../../../../../../drivers/taishan/mmc/core/: mmc_sdhci.c
    ../../../../../../drivers/taishan/mmc/host/: sdhci.c mmc_sehc.c
    ../../../../../../drivers/taishan/pinctrl/: taishan_pinctrl.c taishan_pinctrl_is.c
    ../../../../../../drivers/taishan/reset/: taishan_reset_drv.c taishan_rstgen.c
    ../../../../../../drivers/taishan/scr/: scr_lld.c
    ../../../../../../drivers/taishan/spi_nor/: taishan_xspi.c taishan_xspi_drv.c
    ../../../../../../drivers/taishan/uart/: sdrv_uart_drv.c sdrv_uart.c
    ../../../../../../drivers/taishan/vic/: sdrv_vic.c
